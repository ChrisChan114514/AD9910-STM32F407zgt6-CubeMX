<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AD9910TRY.ewp</path>
  </project>
  <batchBuild />
</workspace>
